# Keil uVision project handle.uvprojx, settings and files
target handle (6190000::V6.19::ARMCLANG)
  device: STM32F031C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: handle +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=27120000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0,STM32F031x6,DEBUG
  c include: ../code/Src;../code/Drivers/STM32F0xx_HAL_Driver/Inc;../code/Drivers/CMSIS/Device/ST/STM32F0xx/Include;../code/Drivers/CMSIS/Include;..\code\Middlewares\aura;..\code\Middlewares\ST\rfal\Inc;..\code\Drivers;..\code\Drivers\ST25R3911;..\code\Middlewares\ST\rfal\Src;..\code\tools
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT5: ROM 0x8007c00 size 0x400
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Drivers/CMSIS
    ../code/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../code/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_crc.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_ll_dma.c stm32f0xx_ll_spi.c stm32f0xx_ll_pwr.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c
  group Drivers/ST25R3911
    ../code/Drivers/ST25R3911/: rfal_rfst25r3911.c st25r3911.c st25r3911_com.c st25r3911_interrupt.c
  group Application/MDK-ARM
    ./: startup_stm32f031x6.s
  group Application/User
    ../code/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f0xx_it.c crc16.c spi_ex.c newlib_dummy.c log.c tick.c timer.c rfid.c usart_ex.c flash.c debug.c
  group Middlewares/rfal
    ../code/Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_dpo.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_t1t.c
  group Middlewares/aura
    ../code/Middlewares/aura/: aura.c uid_hash.c keys.c access.c err.c
software components: CMSIS:CORE 5.6.0
